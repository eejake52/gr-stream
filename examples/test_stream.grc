options:
  parameters:
    generate_options: qt_gui
    id: test_stream
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: input_select
  id: variable_qtgui_chooser
  parameters:
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '440'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '880'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {}
- name: stream_select_0
  id: stream_select
  parameters:
    ins: input_select
    qty: '2'
  states: {}

connections:
- [analog_sig_source_x_0, '0', stream_select_0, '0']
- [analog_sig_source_x_0_0, '0', stream_select_0, '1']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [stream_select_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
